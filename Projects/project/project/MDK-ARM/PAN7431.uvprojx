# Keil uVision project PAN7431.uvprojx, settings and files
target PAN7431 (6240000::V6.24::ARMCLANG)
  device: PY32F030x8 Puya
  pack: Puya.PY32F0xx_DFP.0.0.4
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(8000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,PY32F030x8
  c include: ..\Inc;..\radio;..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\Drivers\PY32F0xx_HAL_Driver\Inc;..\..\..\..\Drivers\BSP\PY32F030xx_Start_Kit;..\..\..\..\Drivers\CMSIS\Device\PY32F0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Common
    ./: startup_py32f030xx.s
    ../Src/: system_py32f0xx.c
  group Application/User
    ../Src/: main.c py32f0xx_hal_msp.c py32f0xx_it.c
    ../Inc/: main.h
  group Source
    ../../../../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_hal.c py32f0xx_hal_adc.c py32f0xx_hal_cortex.c py32f0xx_hal_dma.c py32f0xx_hal_flash.c py32f0xx_hal_gpio.c py32f0xx_hal_iwdg.c py32f0xx_hal_pwr.c py32f0xx_hal_rcc.c py32f0xx_hal_tim.c py32f0xx_hal_uart.c py32f0xx_hal_tim_ex.c
  group radio
    ../radio/: pan211.c pan211.h
  group Doc
    ../: readme.txt
  group APP
    ../../app/: adc.c adc.h app.h base.c base.h config.c config.h curve_table.h eventbus.c eventbus.h gpio.c gpio.h iwdg.c iwdg.h protocol.c protocol.h pwm.c pwm.h
  group Bsp
    ../../bsp/: bsp_flash.c bsp_flash.h bsp_pcb.c bsp_pcb.h bsp_timer.c bsp_timer.h bsp_tm5020a.c bsp_tm5020a.h bsp_uart.c bsp_uart.h bsp_zero.c bsp_zero.h
  group Device
    ../../device/: device_manager.c device_manager.h panel.c panel.h setter.c setter.h repeater.c repeater.h
software components: CMSIS:CORE 6.1.1
